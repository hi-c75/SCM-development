# Keil uVision project 按键系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 按键系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: mian.c lcd.c key.c save.c
